# Keil uVision project Project.uvprojx, settings and files
target STM32L4R9I-Discovery (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L4R9AIIx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IRAM(0x20000000-0x2009FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L4R9xx,LV_CONF_INCLUDE_SIMPLE,EVM_LANG_ENABLE_JAVASCRIPT,EVM_LANG_ENABLE_CSS,EVM_LANG_ENABLE_HML,CONFIG_EVM_ECMA_OBJECT,CONFIG_EVM_ECMA_ARRAY,CONFIG_EVM_ECMA_NUMBER,CONFIG_EVM_ECMA_STRING,CONFIG_EVM_ECMA_TIMEOUT
  c misc: --gnu
  c include: ../Inc;..\..\Drivers\CMSIS\Include;../../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../../Drivers/STM32L4xx_HAL_Driver/Inc;../../Drivers/BSP/STM32L4R9I-Discovery;../../Drivers/BSP/Components/Common;..\..\Middlewares\Third_Party\FatFs\src;..\Src;..\..\modules\ecma\inc;..\..\modules\hml;..\..\modules\hml\frameworks;..\..\..\evm\libevm;..\..\lvgl;..\..\Drivers\BSP\Components\mfxstm32l152
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: RAM 0x68000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xa0000
  group Drivers/BSP/STM32L4R9I-Discovery
    ../../Drivers/BSP/STM32L4R9I-Discovery/: stm32l4r9i_discovery_io.c stm32l4r9i_discovery.c stm32l4r9i_discovery_sd.c stm32l4r9i_discovery_psram.c stm32l4r9i_discovery_ts.c
    ../Inc/: stm32l4xx_hal_conf.h
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_dsi.c stm32l4xx_hal_gfxmmu.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_ltdc.c stm32l4xx_hal_ltdc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_sram.c stm32l4xx_ll_fmc.c
  group Drivers/BSP/Components
    ../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c
    ../../Drivers/BSP/Components/ft3x67/: ft3x67.c
  group Example/User
    ../Src/: stm32l4xx_it.c main.c stm32l4xx_hal_msp.c sd_diskio.c evm_main.c lvgl_main.c lv_conf.h malloc.c
  group Example/MDK-ARM
    ./: startup_stm32l4r9xx.s
  group Middlewares/FatFs/core
    ../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group Middlewares/FatFs/options
    ../../Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group lv_core
    ../../lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
  group lv_draw
    ../../lvgl/src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
  group lv_font
    ../../lvgl/src/lv_font/: lv_font.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_fmt_txt.c
  group lv_hal
    ../../lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group lv_misc
    ../../lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
  group lv_themes
    ../../lvgl/src/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c
  group lv_widgets
    ../../lvgl/src/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
  group ecma
    ../../modules/ecma/src/: ecma.c ecma_array.c ecma_number.c ecma_object.c ecma_string.c ecma_timeout.c
  group hml
    ../../modules/hml/: hml_module.c
    ../../modules/hml/lvgl/: hml_lvgl_utils.c hml_lvgl_module.c
    ../../modules/hml/lvgl/widgets/: lv_marquee.c
    ../../modules/hml/frameworks/: js_app.c js_fwk_module.c js_page_state.c js_page_state_machine.c js_router.c
  group evm
    ../../../evm/libevm/: compiler.c cssparser.c evm.c gc.c hmlparser.c jsparser.c native.c
software components: CMSIS:CORE 4.3.0
